options:
  parameters:
    author: jesus346
    generate_options: qt_gui
    id: FMWideBand
    output_language: python
    title: FM WideBand
  states: {}

blocks:
- name: Ruido
  id: variable_qtgui_range
  parameters:
    label: Ruido
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    label: 'Cutoff Freq:'
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: 48e3/2
    value: 20e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    label: Vol
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2.5'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate*10*2
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jesus346/Escritorio/Audio
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: Ruido
    seed: '0'
    taps: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '2'
    gain: '1'
    samp_rate: samp_rate*2
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Rx
  states: {}
- name: note_1
  id: note
  parameters:
    note: Tx
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '1024'
    gui_hint: widget@0
    label1: Espectro señal información
    name: Señal Información
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*10*2
    fc: '0'
    fftsize: '1024'
    gui_hint: widget@0
    label1: Espectro Señal Modulada
    name: Señal Modulada
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*10*2
    fc: '0'
    fftsize: '1024'
    gui_hint: widget@1
    label1: Espectro Señal Modulada
    name: Señal Modulada
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '1024'
    gui_hint: widget@1
    label1: Espectro Señal Información
    name: Señal Información
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    gui_hint: widget@0
    label1: Señal información
    name: Señal Información
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: widget@0
    label1: Señal Modulada(Real)
    label2: Señal Modulada(Imaginaria)
    name: Señal Modulada
    size: '1024'
    srate: samp_rate*10*2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: widget@1
    label1: Señal Modulada Recibida(Real)
    label2: Señal Modulada Recibida(Imaginaria)
    name: Señal Modulada Recibida
    size: '1024'
    srate: samp_rate*10*2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    gui_hint: widget@1
    label1: Señal Información
    name: Señal Información
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}
- name: widget
  id: qtgui_tab_widget
  parameters:
    label0: Transmisor
    label1: Receptor
    num_tabs: '2'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [channels_channel_model_0, '0', analog_wfm_rcv_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
