options:
  parameters:
    author: jesus346
    generate_options: qt_gui
    id: AM
    output_language: python
    title: Modulación AM
  states: {}

blocks:
- name: Noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: ptt
  id: variable_qtgui_push_button
  parameters:
    label: Press To Talk (PTT)
    pressed: '0'
    released: '1'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volumenEntrada
  id: variable_qtgui_range
  parameters:
    label: Volumen Señal Entrada
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
    widget: dial
  states: {}
- name: volumenSalida
  id: variable_qtgui_range
  parameters:
    label: Volumen Señal Salida
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
    widget: dial
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*16
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumenEntrada
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volumenSalida
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '16'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ptt
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: Noise
    seed: '0'
    taps: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    decim: '16'
    samp_rate: samp_rate*16
    taps: firdes.low_pass(2,samp_rate*16,samp_rate/2,1000)
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Tx
  states: {}
- name: note_1
  id: note
  parameters:
    note: Rx
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*16
    color1: '"red"'
    fc: '0'
    fftsize: '4096'
    gui_hint: tab@0
    label1: Señal de Audio
    name: Espectro Señal Información
    type: float
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    gui_hint: tab@1
    label1: Señal Demodulada
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*16
    fc: '0'
    fftsize: '4096'
    gui_hint: tab@0
    label1: Señal Modulada
    name: Espectro Señal Modulada
    type: float
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*16
    fc: '0'
    fftsize: '4096'
    gui_hint: tab@1
    label1: Señal Modulada
    name: Espectro Señal Modulada Recibida
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    gui_hint: tab@0
    label1: Señal Información
    name: Señal información
    size: '4096'
    srate: samp_rate*16
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab@0
    label1: Señal Modulada
    name: Señal Modulada
    size: '4096'
    srate: samp_rate*16
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab@1
    label1: Señal Modulada(Real)
    label2: Señal Modulada(Compleja)
    name: Señal Modulada Recibida
    size: '4096'
    srate: samp_rate*16
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: tab@1
    label1: Señal Demodulada
    size: '256'
    srate: samp_rate
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Transmisor
    label1: Receptor
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', blocks_selector_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_1, '0', low_pass_filter_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0, '1']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0, '0', blocks_repeat_0, '0']
- [channels_channel_model_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
