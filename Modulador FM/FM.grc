options:
  parameters:
    generate_options: qt_gui
    id: FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    label: beta
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/jesus346/Escritorio/audioRecibido
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jesus346/Escritorio/Audio
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy
      from numpy import float32,complex64,pi,exp
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, frecuencia_normalizada=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Modulador FM',   # will show up in GRC
                  in_sig=[float32],
                  out_sig=[complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.frecuencia_normalizada = frecuencia_normalizada
              self.muestra_anterior = 0

          def work(self, input_items, output_items):
          
              """Integrador y Modulador"""
              for i in range(0,len(input_items[0])):
              	
              	"""Integramos"""
              	ys = self.muestra_anterior + input_items[0][i]
              	self.muestra_anterior = ys
              	"""Modulador"""
              	output_items[0][i] = exp(1j*2*pi*self.frecuencia_normalizada*ys)
              	
              return len(output_items[0])
    frecuencia_normalizada: beta
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Frecuencia_Normalizada: beta
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy
      from numpy import angle, pi, complex64, float32
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, Frecuencia_Normalizada=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Demodulador FM',   # will show up in GRC
                  in_sig=[complex64],
                  out_sig=[float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.frecuencia_normalizada = Frecuencia_Normalizada
              self.muestra_anterior = 1

          def work(self, input_items, output_items):
              
              for i in range(0,len(input_items[0])):
                  """Derivador de Fase"""
                  y = input_items[0][i]*self.muestra_anterior
                  self.muestra_anterior = input_items[0][i].conjugate()
              	
                  """Modulador"""
                  output_items[0][i] = angle(y)/(2*pi*self.frecuencia_normalizada)
              	
              	
              return len(output_items[0])
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Espectro Señal Modulada
    name: Señal Modulada
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Señal Modulada(Real)
    label2: Señal Modulada (Compleja)
    name: Señal Modulada
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Señal Información Recibida
    label2: Señal Información Transmitida
    name: Señal Transmitida y Recibida
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', epy_block_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_1, '1']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', blocks_wavfile_sink_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
