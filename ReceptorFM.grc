options:
  parameters:
    generate_options: qt_gui
    id: ReceptorFM
    output_language: python
    title: ReceptorFM
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0
    label: beta
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0
    label: freq
    orient: Qt.Horizontal
    start: '88000000'
    step: '1'
    stop: '120000000'
    value: '92500000'
  states: {}
- name: low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1000'
    samp_rate: samp_rate*12
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate*12
    tau: '50e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate*12
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/jesus346/Escritorio/audioRecibidoC
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_sink_2
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/jesus346/Escritorio/audioRecibido
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Frecuencia_Normalizada: beta
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy
      from numpy import angle, pi, complex64, float32
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, Frecuencia_Normalizada=75000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Demodulador FM',   # will show up in GRC
                  in_sig=[complex64],
                  out_sig=[float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.frecuencia_normalizada = Frecuencia_Normalizada
              self.muestra_anterior = 1

          def work(self, input_items, output_items):
              
              for i in range(0,len(input_items[0])):
                  """Derivador de Fase"""
                  y = input_items[0][i]*self.muestra_anterior
                  self.muestra_anterior = input_items[0][i].conjugate()
                  
              	
                  """Modulador"""
                  output_items[0][i] = y.imag/(2*pi*self.frecuencia_normalizada)
              	
              	
              return len(output_items[0])
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '12'
    taps: low_pass
    type: fff
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '131072'
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '100'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*12
    uri: usb:1.3.5
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '1310720'
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '100'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*12
    uri: usb:1.3.5
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*12
    type: fir_filter_ccf
    width: '4410'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*12
    type: fir_filter_ccf
    width: '44100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '3'
    gain: '0.6'
    samp_rate: samp_rate*4
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*12
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0
    label1: Espectro Señal Modulada Recibida
    name: Señal Recibida
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*4
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,0
    label1: Espectro Señal Demodulada
    name: Señal Demodulada
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,0
    label1: Espectro Señal Demodulada
    name: Espectro Señal Demodulada
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,0
    label1: Espectro Señal Información
    name: Espectro Señal Información
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,0
    label1: Espectro Señal Información
    name: Señal Información
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*12
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0
    label1: Espectro Señal Recibida Paso bajo
    name: Espectro Señal Recibida Paso bajo
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*12
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0
    label1: Espectro Señal Recibida Paso bajo
    name: Espectro Señal Recibida Paso bajo
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*12
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0
    label1: Espectro Señal Recibida
    name: Espectro Señal Recibida
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0
    label1: Señal Modulada Recibida(Real)
    label2: Señal Modulada Recibida(Imaginaria)
    name: Señal Recibida
    size: '1024'
    srate: samp_rate*12
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,0
    label1: Señal Demodulada
    name: Señal Demodulada
    size: '1024'
    srate: samp_rate*4
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,0
    label1: Señal Demodulada
    name: Señal Demodulada
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 6,0
    label1: Señal Información
    name: Señal Información
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 6,0
    label1: Señal Información
    name: Señal Información
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0
    label1: Señal Recibida Paso Bajo(Real)
    label2: Señal Recibida Paso Bajo (Imaginaria)
    name: Señal Recibida Paso Bajo
    size: '1024'
    srate: samp_rate*12
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0
    label1: Señal Recibida Paso Bajo (Real)
    label2: Señal Recibida Paso Bajo (Imaginaria)
    name: Señal Recibida Paso Bajo
    size: '1024'
    srate: samp_rate*12
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0
    label1: Señal Recibida (Real)
    label2: Señal Recibida (Imaginaria)
    name: Señal recibida
    size: '1024'
    srate: samp_rate*12
    type: complex
  states: {state: disabled}

connections:
- [analog_fm_deemph_0, '0', fft_filter_xxx_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', analog_fm_deemph_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_wavfile_sink_1, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0_0, '0', low_pass_filter_0_0, '0']
- [iio_pluto_source_0_0, '0', qtgui_freq_sink_x_0_2, '0']
- [iio_pluto_source_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_1, '0']
- [low_pass_filter_0_0, '0', epy_block_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [low_pass_filter_1, '0', blocks_wavfile_sink_2, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0_0_1, '0']

metadata:
  file_format: 1
